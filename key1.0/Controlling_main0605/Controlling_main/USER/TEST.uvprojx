# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\24CXX;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\SPI;..\HARDWARE\WKUP;..\HARDWARE\RS485;..\HARDWARE\GPS;..\HARDWARE\SIM900A;..\HARDWARE\MALLOC;..\HARDWARE\DMA;..\USER;..\HARDWARE\MBI5025;..\HARDWARE\STMFLASH;..\HARDWARE\FLASH;..\HARDWARE\ds1339;..\USER
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c config.c control.c Entdata.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/24CXX/: iic.c
    ../HARDWARE/ds1339/: ds1307.c
    ../HARDWARE/DMA/: dma.c
